<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32_to_st8500_test.ewp</path>
  </project>
  <batchBuild />
</workspace>
